Commit message: Fixed rot

File: urdf/table_module.urdf (robot description, URDF)
Before this commit: robot table_module, 3 links, 2 joints
Joints:
- joint table_pnp_joint: origin xyz=0.0 -0.240 -0.047 rpy=0 0 1.57 -> xyz=0.0 -0.240 -0.047 rpy=0 0 0
